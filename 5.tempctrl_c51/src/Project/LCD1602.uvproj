# Keil uVision project LCD1602.uvproj, settings and files
target IK-STC8 (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: LCD1602 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Source;..\User
  group USER
    ../User/: main.c
  group SOURCE
    ../Source/: delay.c lcd1602.c dht11.c uart.c key.c fire.c beep.c MQ-2.c led.c
  group DOC
    ../Doc/: ReadMe.txt
